# Keil uVision project STM32F4_DISCO_BSP.uvprojx, settings and files
target STM32F4-DISCO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4_DISCO_BSP
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group RTOS-BSP
    ./: STM32F4_RTOS_BSP.h STM32F4_RTOS_BSP.c main.c GLCD_ST7735.c GLCD_ST7735.h Abstract.txt
software components: CMSIS:CORE 5.0.2, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SPI 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:Startup 2.6.0
